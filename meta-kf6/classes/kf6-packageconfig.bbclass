PACKAGECONFIG[kauth] = ", , kauth6 kauth6-native"
PACKAGECONFIG[kcmutils] = ", , kcmutils6 kcmutils6-native"
PACKAGECONFIG[kconfig] = ", , kconfig6 kconfig6-native"
PACKAGECONFIG[kcoreaddons] = ", , kcoreaddons6 kcoreaddons6-native"
PACKAGECONFIG[kdoctools] = ", , kdoctools6 kdoctools6-native libxslt-native karchive6-native"
PACKAGECONFIG[ki18n] = ", , ki18n6 ki18n6-native gettext-native"
PACKAGECONFIG:append = " ki18n"

# polkit-qt6-1
