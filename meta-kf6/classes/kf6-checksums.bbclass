SRCREV = "${SRCREV_${KF6_MODULE}}"

# kapidox-6.32.0	193kB	b85b295a4fe1b2fc144affed6785e85bb530268b2ada1df930c65127f73edf4c

## tier 1
SRC_URI[attica6.sha256sum]             = "4f2b525649c6a23924bdf2647e9cd6c591285d33d8d4f01db45b37622e3b839b"
SRC_URI[bluez-qt6.sha256sum]           = "53f9705366f1e142e921f3ec314d673d51341bd20d358c33ebe8fe4218d2cd6b"
SRC_URI[breeze-icons6.sha256sum]       = "3e14087f180ece104dbf9cb23f2c7140759b9dd7c35d8d9defdfcfdee538628f"
SRC_URI[ecm-kf6.sha256sum]             = "305f4e2b82eb073be6ac3e50ace85578b3c0c409be262ccc51d445449e3d9312"
SRC_URI[karchive6.sha256sum]           = "30687d9be0aea05a4ef887212abd91d7c4337cb9f166610f98eac2b01407fb1f"
SRC_URI[kcalendarcore6.sha256sum]       = "65c7b0111140833a0a54cbbc303890e03d3d91469ace4e272e1b76aa2135dba7"
SRC_URI[kcodecs6.sha256sum]            = "2fc1ab6900df8488fe69811fde58ab37c7c6fdf6c1f1b32a01c20f3b3d9f6d9c"
SRC_URI[kconfig6.sha256sum]            = "5ec91eeb6b02db8a8c2e31e3ffdd85165bfa815729a45ca11922369098fd3fcf"
SRC_URI[kcoreaddons6.sha256sum]        = "f7373a77afae97099de4359fba13987b46618ccb952f94ddc11c9d31277fe651"
SRC_URI[kdbusaddons6.sha256sum]        = "84dd9e0775ccff18eb751f6a86ea909bf9eb4a95596baef097684b6646e33764"
SRC_URI[kdnssd6.sha256sum]             = "60f8de14e4a6026c5e843355a180dadd038d6efe41eb9c9a2444971915466b41"
SRC_URI[kglobalaccel6.sha256sum]       = "d5ad10eb041ef8f46074bb1df4cf3475888421d849bc667a7afc6c5bf8cc1640"
SRC_URI[kguiaddons6.sha256sum]         = "ea1bf879d181e498d1786451234a0e58827f35cfb4c667661412cd551741e81a"
SRC_URI[kholidays6.sha256sum]          = "a6aeede0b1c5bba93f7e60d7c6fe84051cb32d90d3981202c4f90237b5fc17a7"
SRC_URI[ki18n6.sha256sum]              = "b574b381e7510cf3b14d6a16f6ed5670220f10df7f2494c21a579d20ca1d017f"
SRC_URI[kidletime6.sha256sum]          = "a7b53ff5a5f80bf8b8869b377de11594c9e5bccf84064c96efd6bab16974c1be"
SRC_URI[kirigami6.sha256sum]           = "1cb13ef3ad1885726c383bcd1a35c494db3e9c2cf87b49398ea34d63129cf6d7"
SRC_URI[kitemmodels6.sha256sum]        = "3a280dbdfc0733ffc9607897109b70b57af89c81dfca534ab92efb948eab3179"
SRC_URI[kitemviews6.sha256sum]         = "fcd869d9e7cea6e296ae0240a6fab07f31762afcc3f427381db703f9fddaef28"
SRC_URI[kplotting6.sha256sum]          = "cc4ef616f4ef7384f7652771998447644789c0f99c507bca81d318443b54c31c"
SRC_URI[kquickcharts6.sha256sum]       = "9f676e504f73fa43e394833e514522baac3f3ca2b8c63908eef7f6bdf1053046"
SRC_URI[ktexttemplate6.sha256sum]      = "074a1616a41600b358e20c40cab16113906c2394600a4fdc62a22696cc3d4156"
SRC_URI[kuserfeedback6.sha256sum]      = "156cadff9de487538440a7f6cfce4a4f0240dc22ccbe4d48f37fb1bd84c75ee5"
SRC_URI[kwidgetsaddons6.sha256sum]     = "53b2f5a65df51be4c15ed14c936aad480ab3e3425a4ea6ed95897ee48e173de9"
SRC_URI[kwindowsystem6.sha256sum]      = "43a32eb940c740f5acc917ce24c4939ba08b9e08c26091dbb5577ad0ef74f3a0"
SRC_URI[modemmanager-qt6.sha256sum]     = "b2be9d84fb6035d79c642c1f6b8196d3f04e673ea61e11deea8bf04213b0fe87"
SRC_URI[networkmanager-qt6.sha256sum]   = "028134ebcb8aba0394377775a15741c8dc3fc33af9651508a6d819ac1e7f31a0"
SRC_URI[prison6.sha256sum]             = "13d904f7514ffe32e49fe09a2b5e10125f825d42c26ee52294c15ce1bfab3970"
SRC_URI[solid6.sha256sum]              = "9620a6065403c5097fce0518abb7d4f038f4f11327e7ce94094ae9561bce0008"
SRC_URI[sonnet6.sha256sum]             = "cae2686b18f41bde6494f353e1dccc5f045e9748b63175a9ff539b3bc93466f1"
SRC_URI[syntax-highlighting6.sha256sum] = "561d01001509299ad0578a02365e6bc714f2799724ac5980bc021c1ec2a44a67"
SRC_URI[threadweaver6.sha256sum]       = "b3ee9e6cdfdb3dec7c7df8e7f66ace6a94e73a531ba4f1d8f7b74360e7201e05"

SRC_URI[oxygen-icons-kf6.sha256sum] = "743b5277c63592d84a51a643e5381d6afbc5c7563ff775faae6005311d1bfccd"
SRC_URI[kapidox6.sha256sum] = "b85b295a4fe1b2fc144affed6785e85bb530268b2ada1df930c65127f73edf4c"


## tier 2
SRC_URI[kauth6.sha256sum]              = "5bcdb298a2ee84bca93a989247fd6d6e34a1e1029caae17705a85b8ac4dbe837"
SRC_URI[kcolorscheme6.sha256sum]       = "235c73afa46669c41cbe2e3a14c5a6ae1f8ad8cbb386b3f65261f65449d2b915"
SRC_URI[kcompletion6.sha256sum]        = "1ec8c0f952af1b18b07c30265610c220acadf429ef1a16558d2c64679b93dcc7"
SRC_URI[kcontacts6.sha256sum]          = "8c67fafff1c9cb84fdc7ca6bb66988e3084bb44ba1b2e5fd0f2ebe40ca8f2198"
SRC_URI[kcrash6.sha256sum]             = "fe627df1797fa92a24e53a7f33de07111c7556070028d39f258035a0c3bdb5df"
SRC_URI[kdoctools6.sha256sum]          = "431b6cb8c419576ed86d38a2488db35c26b720abf7b6f9bc2cfd28056229a10d"
SRC_URI[kfilemetadata6.sha256sum]      = "f74fcb857e52613095d9b264ac6e8ddf0eca326c884e8c83fd536e70b111241a"
SRC_URI[kimageformats6.sha256sum]      = "298069eab84d34b909fc271d818b0762c6c63cc8490f2d8b0fe48dc0d8804b5c"
SRC_URI[kjobwidgets6.sha256sum]        = "98eaee2846181b82b357067db00ac65e3bcf02c11322bb636aa6021a6eb65dd2"
SRC_URI[knotifications6.sha256sum]     = "5da86674bfbe532427f2ea52c86e6d5220cdfb8d0fadb8cbec2ba53d48ec5be9"
SRC_URI[kpackage6.sha256sum]           = "f3959f4a5956a29ce9bd083410d7df63d4f93a1a4e451cb87c2ccf834995e3ca"
SRC_URI[kpty6.sha256sum]               = "ed8a6feee493a1b98930fb78d40e09a5a7983ec2f29ced0afc83ffbdb54f6152"
SRC_URI[kstatusnotifieritem6.sha256sum] = "46c9ebf7d5319a2bde9123427edb277b871740f4f79f65e79a382dde7e1891d9"
SRC_URI[kunitconversion6.sha256sum]    = "af5e72a5cf7ee3d036e045441fc84a5e9c142be6d46bd36c1490d1cec5e7ecfd"
SRC_URI[syndication6.sha256sum]        = "a1fc7e412e56ed9e457edd8c7295865007f89ea082c829245667f5321babfdf0"

SRC_URI[kmime6.sha256sum] = "390870842f4b6afeab01a0f76b63e22f0b97f788f8815d847a43d7a4f23e7941"

## tier 3
SRC_URI[baloo6.sha256sum]              = "305c0e41dab070cac27d2e9530a81aab95157dd76c1c00ffe87d1ad08734dad7"
SRC_URI[kbookmarks6.sha256sum]         = "a796db0d6f91bd8795ef3319f85f75074d76be315119335c339cf37c1552a472"
SRC_URI[kcmutils6.sha256sum]           = "473395787e6921d37298e191cc1718f8818f630b98bdf312583ad25606f6a09e"
SRC_URI[kconfigwidgets6.sha256sum]     = "9d7f60aec2c8153e944d0916852942abb7a28459146b1383f3c540e49dd3da8d"
SRC_URI[kdav6.sha256sum]               = "58c91b163ccc680bf04e2b72112eafef623d51b8b74eec14ab4faad109691612"
SRC_URI[kdeclarative6.sha256sum]       = "9e187056b3e1d49ecde29b30e4a4f5f2633639b622dd596369eac86c45c7f167"
SRC_URI[kded6.sha256sum]               = "eade144d1e197b883529f7e262035134d7ff46b859d0beff34ab778cb5ef683b"
SRC_URI[kdesu6.sha256sum]              = "db3f46d8f293be7e2d4ccf6dd3da724b691fb6f816bd96352f65a72ed838c08a"
SRC_URI[kiconthemes6.sha256sum]        = "1bd4fe3246af5527c136afc650703e5231b8b2de32ca1eac48fa310adece8db8"
SRC_URI[kio6.sha256sum]                = "d16d302a3db7a140703082f0a9a7c7127a5bff795c497f2ae7f8cbb53b100b59"
SRC_URI[knewstuff6.sha256sum]          = "91ee15856bb831d1f4022fb45c8b29b15be6e9330bbc8447fadeee9d6f16ab27"
SRC_URI[knotifyconfig6.sha256sum]      = "708e19857b4ac7ccf82541319d2a3bac30c1b451e79e4b0c71e6f58bc1b5307a"
SRC_URI[kparts6.sha256sum]             = "f2e437b038a0b0b3c40f0dfc81eb5689542c2d4e1f6025436a29e17f11caa79d"
SRC_URI[kpeople6.sha256sum]            = "05ed43d73895e5f4bcc0f56076270f4c44a6ad7ffaf7b3bba2ca861ff9618d6c"
SRC_URI[krunner6.sha256sum]            = "5f9729b5f160fdf17c676b8dd1c5edad861576d4793c1a20cd0cb23ff9d2052b"
SRC_URI[kservice6.sha256sum]           = "495545ac7120305e3c13d5d1c7760c5607527db5816c6ceedf8c9a623b051e2e"
SRC_URI[ksvg6.sha256sum]               = "8299498d46373a84811d29415f9e5a115f491bd7b5fa11c1648fc36ca9374ad6"
SRC_URI[ktexteditor6.sha256sum]        = "13d906ecac31158eb68a6d6315a64948a3e79282d6c9316e82fc38c86640d084"
SRC_URI[ktextwidgets6.sha256sum]       = "7d8bf911d600bd695d2c9a9bdd0ff26e40092195aa18926adf89aef46a330e84"
SRC_URI[kwallet6.sha256sum]            = "d68f74617519d1ebc88f152c29d51333f600b9f0aa8757c0a4fe49a40a5107fa"
SRC_URI[kxmlgui6.sha256sum]            = "3b9be65d4f30e372bc9b77321da5a31dec9fe997a946a6a8a03b64377856ab38"
SRC_URI[purpose6.sha256sum]            = "607b7cb63730a97d447454b17713b73ba7d237aa033b5580e247cc753dbf35e1"
SRC_URI[qqc2-desktop-style6.sha256sum] = "57269c662c25d0ccea96e128a54bc57c3abe0b6b97ef586ea1195c147afc3a38"

## tier 4
SRC_URI[frameworkintegration6.sha256sum] = "874e13434e808cb0b2081af0f993e09236d0c3e44a6ae37d4fe724ee7547a912"




