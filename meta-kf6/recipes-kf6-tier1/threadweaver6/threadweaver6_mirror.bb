SUMMARY = "High-level multithreading framework for KDE and Qt applications"
DESCRIPTION = "ThreadWeaver provides a high-level framework for managing \
concurrent tasks and multithreaded execution in Qt applications. It \
simplifies parallel processing through job scheduling, dependency management, \
and thread pool management, allowing applications to execute asynchronous \
workloads efficiently without directly managing individual threads."
HOMEPAGE = "https://api.kde.org/frameworks/threadweaver/html/index.html"
SECTION = "libs"

LICENSE = "LGPL-2.0-or-later"
inherit kf6
