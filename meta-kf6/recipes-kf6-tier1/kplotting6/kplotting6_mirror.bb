SUMMARY = "Lightweight plotting framework for KDE and Qt applications"
DESCRIPTION = "KPlotting provides a lightweight framework for creating \
two-dimensional plots and data visualizations in KDE and Qt applications. \
It supports plotting data points, curves, axes, grid lines, and labels \
through customizable Qt widgets. The framework simplifies the creation \
of scientific, mathematical, and statistical graphs without requiring \
complex external plotting libraries."
HOMEPAGE = "https://api.kde.org/frameworks/kplotting/html/index.html"
SECTION = "libs"
LICENSE = "LGPL-2.0-or-later"
inherit kf6
