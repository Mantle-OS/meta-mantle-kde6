SUMMARY = "Open Collaboration Services client library for KDE and Qt applications"
DESCRIPTION = "Attica provides a Qt-based client library for interacting \
with services implementing the Open Collaboration Services (OCS) API. \
It enables KDE and Qt applications to discover, download, upload, \
and manage community-generated content such as themes, wallpapers, \
plugins, and other resources. The framework supports user authentication, \
content ratings, comments, and integration with online content providers."

HOMEPAGE = "https://api.kde.org/frameworks/attica/html/index.html"
SECTION = "libs"

LICENSE = "LGPL-2.0-or-later AND (LGPL-2.1-only OR LGPL-3.0-only OR LicenseRef-KDE-Accepted-LGPL)"

inherit kf6
