SRCREV = "${SRCREV_${PLASMA6_MODULE}}"

# kup
SRC_URI[bluedevil6.sha256sum] = "52c3bdbe75f986b796fabf326c4414a07d0fecb5fb066844c5673c0b91fbb36b"
SRC_URI[breeze6.sha256sum] = "1d47a61f9f397f212d7a23d7ed7a7289b026757a050610304bb945dc067937e2"
SRC_URI[discover6.sha256sum] = "cfb851d648d634622ed7df686110678ecd915bc893f0dda5a59a4f94c4258807"
SRC_URI[kactivitymanagerd6.sha256sum] = "ace8726d6a3f95769dd3c8614d4c0a432ce756bd60ab12584b2d13280db471f1"
SRC_URI[kde6-cli-tools-kde6.sha256sum] = "2d702d018e895ecf879d5827d75944563a12ab27244f231bab6c5a40c7656c76"
SRC_URI[kdecoration6.sha256sum] = "77435cc9dda43ff14e6b99cfb08498ace7730f995fc4ab4c21d6be2d1a6c73a1"
SRC_URI[kgamma6.sha256sum] = "1bc752415d4711580f483f774a62d8959583686b93b164484a89d7d5571334a6"
SRC_URI[kglobalacceld6.sha256sum] = "e0fa8b3d951e85d1713e92f4d5c0622a5b0cd441a50383b8b26ac25cceab45c6"
SRC_URI[kpipewire6.sha256sum] = "6b3175c928322e2084f8c40e51c05c24e3823b05195ff6de7db27c130a19c12f"
SRC_URI[krdp6.sha256sum] = "8a80e5a5e0f3e7b665752a60264ac36367431d6d8865cd5797370010a819a40b"
SRC_URI[kscreen6.sha256sum] = "866dead8b6bb3f974a64f18c930e219b358118213e510fcdaabafc37ee7a8a73"
SRC_URI[kscreenlocker6.sha256sum] = "03c61481bb8934c6beaf8f8dd986d2679c0f59f8336e548d85f0872b767edf01"
SRC_URI[ksystemstats6.sha256sum] = "7126e4174d064e48652e95d2f534daffb03b439c78b16385ed350616efa812e0"
SRC_URI[kwallet-pam6.sha256sum] = "c72d451babc36b0b784ba8e2bad02dd52e416f21a89b7372444ec28afc772ea7"
SRC_URI[kwayland6.sha256sum] = "00090254b86f1774e296b4dc7d69d073ee08efb75419c9b5d0955eeae0378a56"
SRC_URI[kwin6.sha256sum] = "fd5cb783f220ea4526a9afee2f72b582c3e87ef7f91b19bc5c7a6662ffe7fbdc"
SRC_URI[layer-shell-qt6-kde6.sha256sum] = "84b31a3e73b150fa611fb51150987600eddd0edc578888e953e7fd37f550643d"
SRC_URI[layer-shell-qt6.sha256sum] = "af3e56be10eb95a5993600449d6c811a08d491f7905c40a1203040b5baf98f9e"
SRC_URI[libkscreen6.sha256sum] = "8f0e2157bb55aa36ac632c85bd4411bcbf2424c477cca3126b8b42ad33fa4fb8"
SRC_URI[libksysguard6.sha256sum] = "a44aa32511a1ce842e8c6adac972f268d662d736650cff6c86360112c4dd2681"
SRC_URI[libplasma6.sha256sum] = "76f081f2d96c7dccf1f29fa0a301572d0115b0c5bec1b32ede0fea4a45c254c4"
SRC_URI[milou6.sha256sum] = "87706400f9f82277cba4aeffbcc8d67e74b89f33038a7d49c0e7db6db3138f86"
SRC_URI[ocean-sound-theme6.sha256sum] = "f13f85e49cac35be429c50e95b21ce281f4a6bba02ecd006a073adcd4f299ab8"
SRC_URI[plasma5support6.sha256sum] = "e97329a0b0d200df15ec30cbf14c8572c72869eef65629a96e8cb3706361d105"
SRC_URI[plasma-activities6.sha256sum] = "bdd3c491e74a2c4b1afa3c8074edfbf8b024b6584c945e56ed9f3a28254c80f1"
SRC_URI[plasma-activities-stats6.sha256sum] = "88681ff26460d3498b966aa3d16f4b9ba60e5571408af6341b46f6da35ec141f"
SRC_URI[plasma-desktop6.sha256sum] = "aa050cfb1005d6f806dc347bb11bc583d5360dd11d51b4501f6328aa7b26d370"
SRC_URI[plasma-disks6.sha256sum] = "56b112d35776a76fb42ab6fd7ad54328eacf5ed396e7342f2bc08744144b6d90"
SRC_URI[plasma-firewall6.sha256sum] = "de78d3c92f8808c7765f072e361037351dc5f9b62f02db8c6f23f06f2d873230"
SRC_URI[plasma-integration6.sha256sum] = "e32e074d79159f584c3098de550a2de46142049234602dffd50596c574816e5b"
SRC_URI[plasma-mobile6.sha256sum] = "d66ef609aaefef6bbe8d6b4b58a98d7322fd2d29b0eabd3539e3066ab770b60c"
SRC_URI[plasma-nano6.sha256sum] = "26f152fc174505de8ad02dfb7e5e4775b0bd817ff8cd87a2ae265ec8526434a9"
SRC_URI[plasma-nm6.sha256sum] = "dd5e6e01efde63220110401f713165c77433ad7fb78664e3c94dc36bb4011554"
SRC_URI[plasma-pa6.sha256sum] = "25ec7e4f2d8104adb4583a30b5d516c699109bc2631b100e549ab1ea5b2607ff"
SRC_URI[plasma-sdk6.sha256sum] = "2b3a4f2e9afd4cfa25398ad697b29612d03d68e3dcbd30b66e505dfa1ec886cc"
SRC_URI[plasma-systemmonitor6.sha256sum] = "f368f843bd0d9d0cd261cda627a98b404268fca6a7e15bad9f69d8e050b004ed"
SRC_URI[plasma-vault6.sha256sum] = "98552279fa15995a1329455f42b8dd1e4397df9f3b95d8ffdfbd2255ce49ebe6"
SRC_URI[plasma-welcome6.sha256sum] = "daa328c588f216ee50db8b1e7fec0d6239c4b06b6b69d4e6225c8677e785a4e8"
SRC_URI[plasma-workspace6.sha256sum] = "3f984e2d960c252ee6353ef639807379c7d1bb2777fecedd047943209c52ffcb"
SRC_URI[polkit-kde6-agent-1-kde6.sha256sum] = "59abbe4c339966f5961daf0f7151b29b67d749c4f7e78e821af287ea96cab4b3"
SRC_URI[powerdevil6.sha256sum] = "c197615be2f1b203ed715ea038e0bafd09d88f7faf3e7cdb5423a519fcfdfe6e"
SRC_URI[qqc2-breeze-style6.sha256sum] = "73501d76471781d1205c6f8e094cadbe9d65443de34246a218a1a802771a9d45"
SRC_URI[systemsettings6.sha256sum] = "0b4f536509aa030bac53230a625320ec56ea7bb418c27e4a093399cfbf8ce9e6"
SRC_URI[xdg-desktop-portal-kde6.sha256sum] = "d7d695716ea101a76dbfccc2b97c07058b9caaa7bbbf8ad96a3ba6fcee84a109"

## MISSING
# SRC_URI[aurorae6.sha256sum] = "cb9f38c36f32587a2821ec539974243d85f9c82909b8e4618b8fffd33761d299"
# SRC_URI[breeze-grub6.sha256sum] = "6191f88b3056c5a4ce25e58c69c292c1bf162a0c221d3e845b378fd9f78d0c23"
# SRC_URI[breeze-gtk6.sha256sum] = "9b96db2c0dd1a6ca018f9bb1cea4ed0947f140cd30f2106d9652448202e47c50"
# SRC_URI[breeze-plymouth6.sha256sum] = "ed14f2f058db20b8cb692ee382428ad58f238c18fb79add7928f5cebe880b6d0"
# SRC_URI[drkonqi6.sha256sum] = "a2072dcfeaae0d948fab951876653ea0036984c7b13a2fe2064dcc9dad7807c6"
# SRC_URI[flatpak-kcm6.sha256sum] = "3433d819c8bd449625ce90012317e47f669f23f91cdfdf28d5328024209a77b5"
# SRC_URI[kde-gtk-config6.sha256sum] = "ce5d555049afbf2162125e1d6ae75a4b9a3ebfa8f87043f94a0a44472da96cb4"
# SRC_URI[kdeplasma-addons6.sha256sum] = "16c03d8e9116b2419a2d183b828cb858a80b5b5a4415b41b7389cadadbd012fa"
# SRC_URI[kinfocenter6.sha256sum] = "f14e80ce9c634ed5316dba727e3216ef734c7f0827dd2140596215009ba31a03"
# SRC_URI[kmenuedit6.sha256sum] = "08a401cec5b0d0c8d918ff72b9e8f0af8f0fc1c72e71f095947f94c6bc2fc333"
# SRC_URI[knighttime6.sha256sum] = "b364a57af1a629d5e09c36a3c859075f8eafa2463201959548fbc362987d7c5f"
# SRC_URI[ksshaskpass6.sha256sum] = "93acd43cc199d26714f770e5e0ce0833aee1db9ed009a3d1e96fdd0eea3e3128"
# SRC_URI[kup6.sha256sum] = "0ece2b1047e874efaec826a67cefcb6c5ac737e89f43be8f4fbce5c77d1b794a"
# SRC_URI[kwayland-integration6.sha256sum] = "d8060c9bf56848e60f96b17d72efe8dd90fa74b9deeed61bc173c7c56cca61c4"
# SRC_URI[kwrited6.sha256sum] = "f3038d5bdee825475ba3ef6c61a63279d7e725c64e6dc00a39eb46759ff9d4ea"
# SRC_URI[oxygen6.sha256sum] = "9356a9718daec6deb552c5b0629f670c7817ba08a83848ad0689d2c321c01b89"
# SRC_URI[oxygen-sounds6.sha256sum] = "faab8fda3e37cd609f51703c9279d7e238f032e9c0df83de227c65bcf19b60d5"
# SRC_URI[plasma-bigscreen6.sha256sum] = "11d1c1c2e613013af049ccce9f5e4a2c238d91052e33bef3ec613708f4cfbec7"
# SRC_URI[plasma-browser-integration6.sha256sum] = "4d5e3aaa7caaa4b82d2c95192e84af4d5f80ba62d0b23414317108f85b1e35ad"
# SRC_URI[plasma-dialer6.sha256sum] = "170ffe28efe3b0d21f71c81eb6e8e16d81c4a2c23fa28f6cbb3b4c6c2d882b46"
# SRC_URI[plasma-keyboard6.sha256sum] = "ec54e6b2d163daf5288cab20ccc7043823dc0e2a3fa431eb2499d7945fa820bb"
# SRC_URI[plasma-login-manager6.sha256sum] = "5969f5a6bbf23a911db5dc1a44cc0ba6f341ce3af8edfe3374d75610b39a8d9d"
# SRC_URI[plasma-setup6.sha256sum] = "12c3562051fe099521b47f408633c649c8d96cc726f1629a81129ec12f895657"
# SRC_URI[plasma-thunderbolt6.sha256sum] = "a9988d8c3e2217a8579484a654d95101fe2477a333ef25316b7696fe4242e6d7"
# SRC_URI[plasma-workspace-wallpapers6.sha256sum] = "fa4ff783f41c8fa08a58d32f094d7acc6c5ac268e23354bd49a40a35617463d6"
# SRC_URI[plymouth-kcm6.sha256sum] = "0ff965e833e3ca33940e0c666a3516345a3ff3dfd71014cbf5b51982c292ae91"
# SRC_URI[print-manager6.sha256sum] = "b5eb208cabbfc02528d57a72a61ea92928ecfb87f7dd261cf614ce8318533b9a"
# SRC_URI[sddm-kcm6.sha256sum] = "e7a069bb70f00af9fc0a4f65ddab9d28d55c209e84431f7dc3e9a444d4543186"
# SRC_URI[spacebar6.sha256sum] = "668707888be2ea845ea400a53b68ce6d9e8f3a368937c5def6eb66bebdf628d4"
# SRC_URI[spectacle6.sha256sum] = "2c412a5e3bd4ecfc5a0a251acb04876030acc6224e08973b0d980d3611b4cb59"
# SRC_URI[union6.sha256sum] = "cebe4d33d23ee3125191ea11130db41f19d4fb9d82fea8c50518906a7ca5279a"

