inherit qt6-paths 

# Define ALL of the paths
KDE6_INSTALL_BINDIR = "${bindir}"
KDE6_INSTALL_SBINDIR = "${sbindir}"
KDE6_INSTALL_LIBDIR = "${libdir}"
KDE6_INSTALL_LIBEXECDIR = "${libexecdir}"
KDE6_INSTALL_CMAKEPACKAGEDIR = "${libdir}/cmake"
KDE6_INSTALL_QTPLUGINDIR = "${QT6_INSTALL_PLUGINSDIR}"
KDE6_INSTALL_QMLDIR = "${QT6_INSTALL_QMLDIR}"
KDE6_INSTALL_INCLUDEDIR = "${includedir}"
KDE6_INSTALL_LOCALSTATEDIR = "${localstatedir}"
KDE6_INSTALL_SHAREDSTATEDIR = "{localstatedir}/lib"
KDE6_INSTALL_DOCBUNDLEDIR = "${datadir}/doc/HTML"
KDE6_INSTALL_KCFGDIR = "${datadir}/config.kcfg"
KDE6_INSTALL_KCONFUPDATEDIR = "${datadir}/kconf_update"
KDE6_INSTALL_KSERVICES6DIR = "${datadir}/kservices6"
KDE6_INSTALL_KSERVICETYPES6DIR = "${datadir}/kservicetypes6"
KDE6_INSTALL_KXMLGUI6DIR = "${datadir}/kxmlgui6"
KDE6_INSTALL_KNOTIFY6RCDIR = "${datadir}/knotifications6"
KDE6_INSTALL_ICONDIR = "${datadir}/icons"
KDE6_INSTALL_LOCALEDIR = "${datadir}/locale"
KDE6_INSTALL_SOUNDDIR = "${datadir}/sounds"
KDE6_INSTALL_TEMPLATEDIR = "${datadir}/templates"
KDE6_INSTALL_WALLPAPERDIR = "${datadir}/wallpapers"
KDE6_INSTALL_APPDIR = "${datadir}/applications"
KDE6_INSTALL_DESKTOPDIR = "${datadir}/desktop-directories"
KDE6_INSTALL_MIMEDIR = "${datadir}/mime/packages"
KDE6_INSTALL_METAINFODIR = "${datadir}/metainfo"
KDE6_INSTALL_QTQCHDIR = "${docdir}"
KDE6_INSTALL_QCHDIR = "${docdir}/qch"
KDE6_INSTALL_MANDIR = "${datadir}/man"
KDE6_INSTALL_INFODIR = "${datadir}/info"
KDE6_INSTALL_DBUSDIR = "${datadir}/dbus-1"
KDE6_INSTALL_DBUSINTERFACEDIR = "${datadir}/dbus-1/interfaces"
KDE6_INSTALL_DBUSSERVICEDIR = "${datadir}/dbus-1/services"
KDE6_INSTALL_DBUSSYSTEMSERVICEDIR = "${datadir}/dbus-1/system-services"
KDE6_INSTALL_CONFDIR = "${sysconfdir}/xdg"
KDE6_INSTALL_SYSCONFDIRAUTOSTARTDIR = "${sysconfdir}/xdg/autostart"
KDE6_INSTALL_LOGGINGCATEGORIESDIR = "${datadir}/qlogging-categories6"
KDE6_INSTALL_SYSTEMDUNITDIR = "${systemd_system_unitdir}"
KDE6_INSTALL_SYSTEMDUSERUNITDIR = "${systemd_user_unitdir}"
KDE6_INSTALL_ZSHAUTOCOMPLETEDIR = "${datadir}/zsh/site-functions"

# mkspecs for ECM
KDE6_INSTALL_MKSPECSDIR = "${QT6_INSTALL_MKSPECSDIR}/"

#EXTRAS (used in packaging not needed in the )
KDE6_INSTALL_LICENSEDIR = "${datadir}/kf6/licenses"
