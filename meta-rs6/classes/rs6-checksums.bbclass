SRCREV = "${SRCREV_${KDE6_RS_MODULE}}"

SRC_URI[alligator6.sha256sum] = "bb39c244f7e26d06d342515a8e69888fbe7a5ea3b7c224ff1f0a0c2718a32d8c"
SRC_URI[angelfish6.sha256sum] = "0926325a19f2cc72e4a54fdacec5eb7cb15044e6129d28d1a959a706ad1c2d7c"
SRC_URI[blinken6.sha256sum] = "659bc69e811c7247e801c0696066bfb8cc9f70e223f401a58b08bb6bd83d35a4"
SRC_URI[dolphin6.sha256sum] = "ddd5e5622594792490695999188c6215c3a0821787c71dfb57dbfdd08e1ce935"
SRC_URI[dragon6.sha256sum] = "b72c06f1ce465dd3d7be47d69ec3a3588ddd464cc0f5d351a8d7ed47c85846a9"
SRC_URI[elisa6.sha256sum] = "76029c54e927873039c3c282ada787a78f1d0d6dbc8fa9bd2e819aeec5df2d5c"
SRC_URI[gwenview6.sha256sum] = "5bf1bfccedef659f4df913adddd64a2c964d39b84cf1427104bb15dbaa86f08e"
SRC_URI[itinerary6.sha256sum] = "1f2c10c1f47a5919f447accdf60997038a528a66b8ee172fcc184dd2bd2f2716"
SRC_URI[kanagram6.sha256sum] = "a8086e3f8a8a8faf40878d439aa754641444d93c8b0d0c529047530abdf46406"
SRC_URI[kasts6.sha256sum] = "c7cb5d3ce480d97b96402d8f9dcfc40c0465a4e1cfe3513fb7ccef78e5eb275c"
SRC_URI[kclock6.sha256sum] = "b0fe8c3a4c423c5ca40d9daef287f1d84498ea6b2acf66af55bdbd77e077f896"
SRC_URI[kdeconnect-kde6.sha256sum] = "edc6d8d5bb3aab53208a229528ef36a5bc959bfaec17512b5621502d1d37d260"
SRC_URI[kdeedu-data6.sha256sum] = "5ef96eeeed941a5cebd9756c6cc1dde888a63c677a1c6250b6a2286070b92066"
SRC_URI[kdialog6.sha256sum] = "7772cdfe2acccfda420c627a8b1f4cf35acc1906f5155fc2166ee482e10755a3"
SRC_URI[khangman6.sha256sum] = "6e0395602370083082525717485fa1030ae7b4e31ecb97ad2035aa3c4788a890"
SRC_URI[kitinerary6.sha256sum] = "635530c31d67fc35f5f5bcdf43f06d896e47b423d02df6546ef3c5fea1d212c6"
SRC_URI[kjournald6.sha256sum] = "5287b36efdc7b124c81c1c6a0523357d660b5d633b7edc139480123ac74616c6"
SRC_URI[kmime6.sha256sum] = "846e6ecd519d99a282f5079c9c153fbbc3d9e6f8698e5a9b31f8dccfe988d1f3"
SRC_URI[kmines6.sha256sum] = "31968a4773da1004f335347b68f00ebb132dc9bd20f8f95c0d90dd94db7480f9"
SRC_URI[koko6.sha256sum] = "4fdb14b1d03e74d65634eef47925fd21216bb4019d189232a9831fabbcdf4fe5"
SRC_URI[kongress6.sha256sum] = "0b72a9b8b885f2730b74fb4e0bc9ce2812d0b92d1e6ea089d74c82db44922637"
SRC_URI[konsole6.sha256sum] = "c880bd2c829437a142abaf4f97ebc384c9f2c19f31cc23918c49100727927450"
SRC_URI[kopeninghours6.sha256sum] = "94bae44259d7566b2a7c26411f3200fc40298bb1fc65d48060aa6a210afc4d50"
SRC_URI[kosmindoormap6.sha256sum] = "46151160bfce5f855e4df6febbdf9e4887f4addd745749dd0888aa9a12d121cb"
SRC_URI[kpkpass6.sha256sum] = "2ee2a25ff90f23026dd687e2b62ac1a908c1c55fdf685a42583d67472a1badbb"
SRC_URI[kpublictransport6.sha256sum] = "fd0190081f4be172711ec1e0e5702805bcf9c00c73a08a42ba3790167cabab0a"
SRC_URI[krecorder6.sha256sum] = "7c2838a0cb6171f273f98f2d0b9b9908163e426f957b8af947506be8d8e2107a"
SRC_URI[krfb6.sha256sum] = "f353c6603046fe97fd0808497d47a3eb18bbd7811e43d08c965414214496845a"
SRC_URI[ktrip6.sha256sum] = "bfcadd7101809c0ae371e0050485c669ad1636440dd22fc352db895a949460b7"
SRC_URI[kweather6.sha256sum] = "acd8d383abc97323a08283f5c34511d05a06b7019320d024968a01ccf6fe2106"
SRC_URI[kweathercore6.sha256sum] = "1b97e95aec8f1930244ae5c400712056109b3ed22fa5b6994834cd714bbe324a"
SRC_URI[kwordquiz6.sha256sum] = "0b3c71fc33526d060976db0e1d4d88b5e965a5bef144ad0be828c783e8f4167d"
SRC_URI[libkdegames6.sha256sum] = "15579343d5b06608115e8e95473b80bc91de8841b1a79584f5615a91fe57e2f7"
SRC_URI[libkeduvocdocument6.sha256sum]  = "b6739f73e41c5df9ee312011985f75bd2e74200e78a7cba771958bb1f029517a"
SRC_URI[libkexiv2-kf6.sha256sum] = "9bb4e5858f35d0dba813ade3c0ff6e7fe750b0930d60a7f4609b48c9563d45eb"
SRC_URI[marble6.sha256sum] = "6f5bf1cebc3311ce2439c4243f90ad249722edf12a96fb927ca60b83e98c7c9a"
SRC_URI[okular6.sha256sum] = "8c70c448e8aa8c55c3623024ee1d70930888672a503c40c60af2de702ffe64fc"
SRC_URI[qmlkonsole6.sha256sum] = "06cb9155536079d40a68cf8e8ac52dc8e686dfb68e9fb2f078c858c1465ca424"
